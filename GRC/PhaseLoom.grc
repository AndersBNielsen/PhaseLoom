options:
  parameters:
    generate_options: qt_gui
    id: PhaseLoom
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 44100/2, 500, 6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,2,width
    label: Frq
    start: '-22050'
    step: '100'
    stop: '22050'
    value: '-1400'
    widget: eng_slider
  states: {}
- name: width
  id: variable
  parameters:
    value: '20'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: Multi-Output Device
    samp_rate: '11025'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: FastTrack Pro
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3200'
    low_cutoff_freq: '200'
    samp_rate: samp_rate/4
    type: fir_filter_ccf
    width: '1'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_correctiq_man_0
  id: blocks_correctiq_man
  parameters:
    imag: '0.0'
    real: '0.0'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: variable_qtgui_range_0
    decim: '4'
    samp_rate: samp_rate
    taps: filter_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,width
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,0,1,width
    size: '4096'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 5,0,1,width
    name: '"I"'
    size: '2048'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 6,0,1,width
    name: '"Q"'
    size: '2048'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,width-1
    legend: 'False'
    showports: 'True'
    type: complex
  states: {}

connections:
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [audio_source_0, '1', qtgui_time_sink_x_0_1, '0']
- [band_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_correctiq_man_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_correctiq_man_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_correctiq_man_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_correctiq_man_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', blocks_correctiq_man_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
